# Keil uVision project Attendance_System.uvproj, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Attendance_System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c delay.c lcd_4bit_driver.c uart0_driver.c uart1_driver.c i2c_driver.c rtc_driver.c uart0_interrupt.c uart1_interrupt.c
